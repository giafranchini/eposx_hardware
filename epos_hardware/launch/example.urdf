Commit message: update example

File: epos_hardware/launch/example.urdf (robot description, URDF)
Before this commit: robot example, 2 links, 1 joints
Joints:
- joint test_joint: limit (none) -> effort=10.0 velocity=10.0; type revolute -> continuous
